## Kconfig
```kconfig
config NETHACK
	bool "nethack"
	select NCURSES
	select UCLIBC_SUSV3_LEGACY
	default y
	help
	  .hL|
	  .D@|
	  -+-|
```
